# Keil uVision project yiyi.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: yiyi +hex
  c flags: Optim=1
  c include: ..\USER;..\SYSTEM;..\INTERFACE;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: yiyi.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c rtc.c
  group INTERFACE
    ../INTERFACE/: usart.c usart2.c
  group HARDWARE
    ../HARDWARE/: LCD12864.c Display.c ds18b20.c Lunar.c
